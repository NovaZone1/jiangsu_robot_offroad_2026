# Keil uVision project jiangsu_robot_offroad_2026.uvprojx, settings and files
target jiangsu_robot_offroad_2026 (6140001::V6.14.1::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: jiangsu_robot_offroad_2026 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=4
  c define: USE_HAL_DRIVER,STM32F103xE,HAL_ADC_MODULE_ENABLED,HAL_UART_MODULE_ENABLED,ARM_MATH_CM3
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../FrameComponets/Bsps/Inc;../FrameComponets/Mods/Inc;../FrameComponets/Sys/Inc;../FrameComponets/Apps/Inc;../FrameComponets/Algorithm/Inc
  asm include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM3/: port.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM3l_math.lib
  group Frame/Bsps
    ../FrameComponets/Bsps/Src/: bsp_adc.c bsp_dwt.c bsp_encoder.c bsp_gpio.c bsp_motor_board.c bsp_oled_bus.c bsp_tim_pwm.c bsp_uart.c bsp_uart1_dma.c bsp_ultrasonic_echo.c
  group Frame/Mods
    ../FrameComponets/Mods/Src/: bluetooth.cpp dc_motor.cpp gray_sensor.cpp gray_yahboom_8lp.cpp led.cpp motor_pwm_driver.cpp nova_protocol.cpp oled_factory.cpp std_actuator.cpp std_sensor.cpp ultrasonic_factory.cpp ultrasonic.cpp
  group Frame/Sys
    ../FrameComponets/Sys/Src/: Action.cpp Application.cpp Monitor.cpp RtosCpp.cpp StateCore.cpp System.cpp
  group Frame/Apps
    ../FrameComponets/Apps/Src/: gray_8lp_example.cpp LineFollowApp.cpp LineFollowBoard.cpp MainFrame.cpp MotorProtection.cpp MotorSpeedDisplay.cpp NovaLink.cpp OffroadApp.cpp SpeedMixer.cpp Track.cpp
  group Frame/Algorithm
    ../FrameComponets/Algorithm/Src/: adrc.cpp hyperPID.cpp pid.cpp signator.cpp std_math.cpp
software components: CMSIS:CORE 5.4.0
